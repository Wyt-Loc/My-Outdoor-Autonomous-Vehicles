# Keil uVision project key.uvproj, settings and files
target KEY (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: key
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\stm32f0;..\user;..\lib\inc;..\lib\src;..\drive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group stm32f0
    ./: startup_stm32f0xx.s
    ../stm32f0/: system_stm32f0xx.c stm32f0xx_it.c
  group user
    ./: main.c
  group drive
    ../drive/: exit.c gpio.c systick.c time.c
  group lib
    ../lib/src/: stm32f0xx_syscfg.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_tim.c
